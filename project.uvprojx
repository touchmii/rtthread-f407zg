# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;packages\CanFestival-v1.0.0\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\none-gcc;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include;packages\CanFestival-v1.0.0\examples\master402;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\include\socket\sys_socket;packages\SEGGER_RTT-v1.1.0;packages\SEGGER_RTT-v1.1.0\RTT;packages\wiznet-latest\inc;packages\wiznet-latest\ioLibrary;packages\wiznet-latest\ioLibrary\Ethernet;packages\wiznet-latest\ioLibrary\Internet
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CanFestival
    packages/CanFestival-v1.0.0/src/: emcy.c pdo.c objacces.c timer_rtthread.c timer.c can_rtthread.c states.c sdo.c nmtSlave.c sync.c lifegrd.c nmtMaster.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: waitqueue.c workqueue.c ringbuffer.c completion.c dataqueue.c ringblk_buf.c pipe.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_can.c drv_spi.c drv_usart.c drv_common.c drv_hwtimer.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: mem.c scheduler.c components.c object.c kservice.c thread.c mempool.c clock.c irq.c timer.c idle.c device.c ipc.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: syscalls.c libc.c mem_std.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_cec.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Master402
    packages/CanFestival-v1.0.0/examples/master402/: master402_canopen.c motor_control.c canopen_callback.c master402_od.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c
  group SEGGER_RTT
    packages/SEGGER_RTT-v1.1.0/adapter/: drv_rtt.c
    packages/SEGGER_RTT-v1.1.0/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group WIZnet
    packages/wiznet-latest/src/: wiz.c wiz_ping.c wiz_device.c wiz_af_inet.c wiz_socket.c
    packages/wiznet-latest/ioLibrary/Ethernet/: wizchip_socket.c wizchip_conf.c
    packages/wiznet-latest/ioLibrary/Internet/DNS/: wizchip_dns.c
    packages/wiznet-latest/ioLibrary/Ethernet/W5500/: w5500.c
